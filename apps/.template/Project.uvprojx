# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Project +hex
  BeforeMake: $K\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ./Application;../../src/include;../../src/drivers/platform/stm32f1/hal/Inc;../../src/drivers/platform/stm32f1/STM32F1xx_HAL_Driver/Inc;../../src/drivers/platform/stm32f1/STM32F1xx_HAL_Driver/Inc/Legacy;../../src/drivers/platform/stm32f1/cmsis/Device/ST/STM32F1xx/Include;../../src/drivers/platform/stm32f1/cmsis/Include;../../src/drivers/platform/stm32f1/board;../../src/drivers/platform/stm32f1/;../../src/drivers/usb;../../src/drivers/usb/core;../../src/drivers/usb/class/CDC;../../src/drivers/video;../../src/drivers/input/misc;../../src/drivers/rtc;../../src/drivers/power;../../src/drivers/sound;../../src/drivers/base;../../src/drivers/input;../../src/drivers/mmc;../../src/fs/fatfs;../../src/include;../../src/kernel
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ./Application/: main.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
    ../../src/drivers/platform/stm32f1/board/: adc.c gpio.c rtc.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../src/drivers/platform/stm32f1/hal/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_usb.c
  group Drivers/CMSIS
    ./Application/: system_stm32f1xx.c
  group Drivers/BSP
    ../../src/drivers/video/: FONT.H GUI.c GUI.h ST7789V.c ST7789V.h
    ../../src/drivers/rtc/: rtc_utils.c rtc_utils.h
    ../../src/drivers/power/: Power.c Power.h
    ../../src/drivers/mmc/: spi_sdcard.c spi_sdcard.h
    ../../src/drivers/input/misc/: Key.c Key.h
    ../../src/drivers/sound/: Buzzer.c Buzzer.h
    ../../src/drivers/input/: input.c
    ../../src/drivers/base/: core.c
    ../../src/fs/: char_dev.c
    ../../src/drivers/tty/: tty_io.c
  group Drivers/USB_Device_Library
    ../../src/drivers/usb/core/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../src/drivers/usb/class/CDC/: usbd_cdc.c
  group Fs/FatFs
    ../../src/fs/fatfs/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group Kernel
    ../../src/include/: bootloader_api.h errno.h kernel.h sys_path.h
    ../../src/kernel/: kernel.c
    ../../src/fs/: vfs.c
software components: CMSIS:CORE 4.3.0
